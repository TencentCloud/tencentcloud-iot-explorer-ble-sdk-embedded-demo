## qcloud-llsync-dual-comm/components/qcloud_iot_c_sdk/Kconfig
```kconfig
menu "QCloud Iot C"
config QCLOUD_IOT_C_SDK

    bool "QCloud Iot C SDK."
    default "y"

endmenu
```
